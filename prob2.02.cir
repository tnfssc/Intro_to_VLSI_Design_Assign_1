.title Problem 1.2
